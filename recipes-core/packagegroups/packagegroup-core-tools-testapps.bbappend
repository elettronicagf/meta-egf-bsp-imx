RDEPENDS:${PN}:remove = "ltp"
RDEPENDS:${PN}:remove = "connman-tools"
RDEPENDS:${PN}:remove = "connman-tests"
RDEPENDS:${PN}:remove = "connman-client" 
