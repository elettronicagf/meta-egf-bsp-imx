PACKAGECONFIG:append:imx-nxp-bsp = " vpx"