KERNEL_MODULE_AUTOLOAD:imx8mp-egf-3sm1009  += "moal"
KERNEL_MODULE_PROBECONF:imx8mp-egf-3sm1009  += "moal"
module_conf_moal:imx8mp-egf-3sm1009 = "options moal mod_para=nxp/wifi_mod_para.conf"


KERNEL_MODULE_AUTOLOAD:imx8mm-egf-3sm1008m   += "moal"
KERNEL_MODULE_PROBECONF:imx8mm-egf-3sm1008m   += "moal"
module_conf_moal:imx8mm-egf-3sm1008m  = "options moal mod_para=nxp/wifi_mod_para.conf"
